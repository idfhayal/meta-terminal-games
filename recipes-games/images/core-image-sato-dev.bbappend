IMAGE_INSTALL_append = " packagegroup-games"
